ALTERNATIVE:${PN} = ""
PACKAGE_NO_LOCALE = "1"
